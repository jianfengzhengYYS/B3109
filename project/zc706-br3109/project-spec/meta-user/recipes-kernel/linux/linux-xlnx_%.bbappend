SRC_URI += "file://user_2023-09-06-00-22-00.cfg \
            file://user_2023-09-06-00-32-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

