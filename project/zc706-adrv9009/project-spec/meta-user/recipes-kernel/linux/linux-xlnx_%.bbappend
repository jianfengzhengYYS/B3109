SRC_URI += "file://user_2023-09-04-04-54-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

